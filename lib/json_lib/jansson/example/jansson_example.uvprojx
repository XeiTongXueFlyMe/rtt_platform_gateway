# Keil uVision project jansson_example.uvprojx, settings and files
target Cortex-M3 Simulation (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: jansson_example
  c flags: Optim=1 wLevel=2
  c include: C:\Keil\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Driver\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c Abstract.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.1, Compiler:I/O:STDOUT 1.0.0, Data Exchange:JSON:Jansson 2.7.0
