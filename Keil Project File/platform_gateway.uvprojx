# Keil uVision project platform_gateway.uvprojx, settings and files
target platform_gateway (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: platform_gateway +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\applications;..\rt_thread\include;..\rt_thread\include\libc;..\rt_thread;..\rt_thread\libcpu\arm\cortex-m3;..\device_drivers\include\drivers;..\device_drivers\include;..\components\utilities\ulog;..\components\utilities\ulog\syslog;..\components\finsh;..\lib\stm32_lib\inc;..\lib\stm32_lib\device_support;..\lib\libc\compilers\armlibc;..\lib\libc\compilers\armlibc\sys
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group applications
    ../applications/: application.c startup.c config.h led.c ulog.c wdg.c reboot.c
  group components
    ../components/utilities/ulog/: ulog.c
    ../components/utilities/ulog/backend/: console_be.c
    ../components/finsh/: cmd.c msh.c shell.c symbol.c msh_cmd.c
  group device_drivers
    ../device_drivers/serial/: serial.c
    ../device_drivers/include/: rtdevice.h
    ../device_drivers/src/: dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c completion.c workqueue.c
    ../device_drivers/watchdog/: watchdog.c
    ../device_drivers/nvm/: nvm.c
    ../device_drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
    ../device_drivers/rtc/: rtc.c soft_rtc.c
  group drivers
    ../drivers/: board.c drv_usart.c drv_gpio_led.c drv_xwdg.c drv_flash.c drv_w25qxx.c dvr_spi3.c
  group rt_thread
    ../rt_thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../rt_thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c core_cm3.c
    ../rt_thread/: rtconfig.h
  group libstm32
    ../lib/stm32_lib/device_support/: stm32f2xx.h
    ../lib/stm32_lib/src/: misc.c startup_stm32f2xx.s stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c system_stm32f2xx.c
  group libc
    ../lib/libc/compilers/common/: gmtime_r.c
    ../lib/libc/compilers/armlibc/: mem_std.c stubs.c time.c
